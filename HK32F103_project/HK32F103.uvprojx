# Keil uVision project HK32F103.uvprojx, settings and files
target HK32F103VE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HK32F103VE HK_MicroChip
  pack: HKMicroChip.HK32F1xx_DFP.1.0.6
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HK32F103 +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HK32F103VEXX
  c include: .\inc;..\HK32F103\HK32F103X_lib\inc;..\HK32F103\CMSIS\HK32F1xx\Include;..\HK32F103\CMSIS\CM3\Core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./src/: hk32f10x_it.c main.c
  group CMSIS
    ../HK32F103/CMSIS/CM3/Core/: core_cm3.c
    ../HK32F103/CMSIS/HK32F1xx/Source/ARM/: startup_hk32f103xE.s
    ../HK32F103/CMSIS/HK32F1xx/Source/: system_hk32f10x.c
  group hk32f103_lib
    ../HK32F103/HK32F103X_lib/src/: hk32f10x_adc.c hk32f10x_bkp.c hk32f10x_can.c hk32f10x_crc.c hk32f10x_dac.c hk32f10x_dbgmcu.c hk32f10x_dma.c hk32f10x_exti.c hk32f10x_flash.c hk32f10x_fsmc.c hk32f10x_gpio.c hk32f10x_i2c.c hk32f10x_iwdg.c hk32f10x_pwr.c hk32f10x_rcc.c hk32f10x_rtc.c hk32f10x_sdio.c hk32f10x_spi.c hk32f10x_tim.c hk32f10x_usart.c hk32f10x_wwdg.c misc.c
