# Keil uVision project demo.uvprojx, settings and files
target demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HK32F103CBT6A HK_MicroChip
  pack: HKMicroChip.HK32F1xx_DFP.1.0.6
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HK32F103,HK32F103CBT6A
  c include: ..\HK32F103\CMSIS\CM3\Core;..\HK32F103\HK32F103X_lib\inc;..\HK32F103_project\inc;..\HK32F103\CMSIS\HK32F1xx\Include;..\package\delay;..\package\I2C;..\package\OLED;..\package\SHT30;..\package\SYS;..\package\WS2812;..\mcu_sdk;..\package\usart
  asm define: HK32F103,HK32F103CBT6A
  asm include: ..\HK32F103\CMSIS\CM3\Core;..\HK32F103\HK32F103X_lib\inc;..\HK32F103\CMSIS\HK32F1xx\Include;..\HK32F103\CMSIS\CM3;..\HK32F103\HK32F103X_lib\templates;..\package
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ../HK32F103/CMSIS/HK32F1xx/Source/: system_hk32f10x.c
    ../HK32F103/HK32F103X_lib/templates/: hk32f10x_it.c
    ../HK32F103_project/src/: main.c
    ../HK32F103_project/inc/: main.h
  group start
    ../HK32F103/CMSIS/HK32F1xx/Source/ARM/: startup_hk32f103xB.s
  group HK32F103X_lib
    ../HK32F103/HK32F103X_lib/src/: hk32f10x_adc.c hk32f10x_bkp.c hk32f10x_can.c hk32f10x_crc.c hk32f10x_dac.c hk32f10x_dbgmcu.c hk32f10x_dma.c hk32f10x_exti.c hk32f10x_flash.c hk32f10x_fsmc.c hk32f10x_gpio.c hk32f10x_i2c.c hk32f10x_iwdg.c hk32f10x_pwr.c hk32f10x_rcc.c hk32f10x_rtc.c hk32f10x_sdio.c hk32f10x_spi.c hk32f10x_tim.c hk32f10x_usart.c hk32f10x_wwdg.c misc.c
  group package
    ../package/I2C/: i2c.c
    ../package/SYS/: sys.c
    ../package/delay/: delay.c
    ../package/OLED/: oled.c
    ../package/SHT30/: sht30.c
    ../package/WS2812/: ws2812.c
    ../package/usart/: usart.c
  group mcu_sdk
    ../mcu_sdk/: mcu_api.c protocol.c system.c
